# Keil uVision project project.uvprojx, settings and files
target rt-thread (ARM-ADS)
  device: STM32F051R8 STMicroelectronics
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x2000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: template +hex
  c flags: Optim=1 OneElfS=1
  c define: RT_USING_ARM_LIBC, USE_STDPERIPH_DRIVER
  c include: .;..\..\components\drivers\include;..\..\components\finsh;..\..\components\init;..\..\components\libc\armlibc;..\..\include;..\..\libcpu\arm\common;..\..\libcpu\arm\cortex-m0;Libraries\CMSIS\Include;Libraries\CMSIS\ST\STM32F0xx\Include;Libraries\STM32F0xx_StdPeriph_Driver\inc;applications;drivers
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  link misc: --keep __fsym_* --keep __vsym_*   --keep __rt_init*
  group Applications
    applications/: application.c startup.c
  group Drivers
    drivers/: board.c stm32f0xx_it.c
    ./Drivers/: drv_led.c drv_encoder.c drv_adc.c drv_timer.c drv_button.c drv_exti.c bk5933.c
    ./drivers/: usart.c usart.h stm32f0xx_conf.h bk5933.h
  group STM32_StdPeriph
    Libraries/CMSIS/ST/STM32F0xx/Source/Templates/: system_stm32f0xx.c
    Libraries/STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_adc.c stm32f0xx_cec.c stm32f0xx_comp.c stm32f0xx_crc.c stm32f0xx_dac.c stm32f0xx_dbgmcu.c stm32f0xx_dma.c stm32f0xx_exti.c stm32f0xx_flash.c stm32f0xx_gpio.c stm32f0xx_i2c.c stm32f0xx_iwdg.c stm32f0xx_misc.c stm32f0xx_pwr.c stm32f0xx_rcc.c stm32f0xx_rtc.c stm32f0xx_spi.c stm32f0xx_syscfg.c stm32f0xx_tim.c stm32f0xx_usart.c stm32f0xx_wwdg.c
    Libraries/CMSIS/ST/STM32F0xx/Source/Templates/arm/: startup_stm32f0xx.s
  group Kernel
    ../../src/: clock.c device.c idle.c ipc.c irq.c kservice.c mem.c object.c scheduler.c thread.c timer.c
  group CORTEX-M0
    ../../libcpu/arm/cortex-m0/: cpuport.c context_rvds.S
    ../../libcpu/arm/common/: backtrace.c div0.c showmem.c
  group DeviceDrivers
    ../../components/drivers/serial/: serial.c
    ../../components/drivers/src/: completion.c dataqueue.c pipe.c portal.c ringbuffer.c workqueue.c
  group finsh
    ../../components/finsh/: shell.c symbol.c cmd.c finsh_compiler.c finsh_error.c finsh_heap.c finsh_init.c finsh_node.c finsh_ops.c finsh_parser.c finsh_var.c finsh_vm.c finsh_token.c
  group Components
    ../../components/init/: components.c
  group libc
    ../../components/libc/armlibc/: mem_std.c stubs.c
